Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2022-12-16T10:21:06
Author: RV-PC\W77
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*400 (33)
In: Undefined
Description: PL2*400; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
Tekla Commun - Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL2*400; Nom: CORNIERE
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.4 m2; Surface nette: 0.1 m2; Hauteur: 400 mm; Largeur: 2 mm; Longueur: 106 mm
BaseQuantities - Length: 106 mm; OuterSurfaceArea: 0.088432 m2; NetVolume: 0.0000864 m3; NetWeight: 0.67824 kg
Name | Niveau bas | Niveau haut
6 x CORNIERE | +4.088 | +4.491
5 x CORNIERE | +4.469 | +4.872
8 x CORNIERE | +2.054 | +2.104
6 x CORNIERE | +4.276 | +4.679
8 x CORNIERE | +0.179 | +0.229

# IfcBeam: PL2*600 (14)
In: Undefined
Description: PL2*600; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL2*600; Nom: CORNIERE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.2 m2; Surface nette: 0.1 m2; Hauteur: 600 mm; Largeur: 2 mm; Longueur: 106 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
BaseQuantities - Length: 106 mm; OuterSurfaceArea: 0.132432 m2; NetVolume: 0.0001296 m3; NetWeight: 1.01736 kg
Name | Niveau bas | Niveau haut
2 x CORNIERE | +4.352 | +4.953
2 x CORNIERE | +4.271 | +4.872
2 x CORNIERE | +4.175 | +4.775
2 x CORNIERE | +4.078 | +4.679
2 x CORNIERE | +3.984 | +4.585
2 x CORNIERE | +3.890 | +4.491
2 x CORNIERE | +3.797 | +4.397

# IfcBeam: PL4*105 (17)
In: Undefined
Description: PL4*105; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Phase: 56; Classe: 3; Matériau: S235JR; Profil: PL4*105; Nom: ATTACHE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67 m2; Surface nette: 0.1 m2; Hauteur: 105 mm; Largeur: 4 mm; Longueur: 290 mm
BaseQuantities - Length: 289.983 mm; OuterSurfaceArea: 0.0649283 m2; NetVolume: 0.000123473 m3; NetWeight: 0.969263 kg
Name | Niveau bas | Niveau haut
2 x ATTACHE | +4.232 | +4.342
2 x ATTACHE | +4.420 | +4.530
2 x ATTACHE | +4.610 | +4.720
2 x ATTACHE | +4.787 | +4.898
2 x ATTACHE | +4.326 | +4.436
2 x ATTACHE | +4.707 | +4.817
2 x ATTACHE | +4.874 | +4.985
2 x ATTACHE | +4.138 | +4.249
ATTACHE | +4.514 | +4.624

# IfcBeam: PL4*150 (16)
In: Undefined
Description: PL4*150; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Matériau: Steel_Undefined; Profil: PL4*150; Nom: AT CROIX
Tekla Quantités - Poids: 2.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.2 m2; Hauteur: 150 mm; Largeur: 4 mm; Longueur: 602 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.18908 m2; NetVolume: 0.000366 m3; NetWeight: 2.8731 kg
Name | Niveau bas | Niveau haut | Phase | Classe
4 x AT CROIX | +0.344 | +0.494 | 265 | 99
4 x AT CROIX | +3.704 | +3.854 | 265 | 99
4 x AT CROIX | +4.592 | +4.823 | 264 | 6
2 x AT CROIX | +3.899 | +4.130 | 264 | 6
2 x AT CROIX | +3.895 | +4.126 | 264 | 6

# IfcBeam: PL4*180 (38)
In: Undefined
Description: PL4*180; Material: STEEL/S235JR
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*180
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 180 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
10 x PLATINE | -0.000 | +0.102 | PL0(?) | 267 | PLATINE | 1 | 66.6 | 0.1 | 166 | 166 | 0.064 | 0.0001224 | 0.96084
2 x PLATINE | +0.000 | +0.102 | PL0(?) | 267 | PLATINE | 1 | 66.6 | 0.1 | 166 | 165.993 | 0.0639976 | 0.000122395 | 0.960803
4 x PLATINE | +0.000 | +0.102 | PL0(?) | 267 | PLATINE | 1 | 66.6 | 0.1 | 166 | 165.987 | 0.0639951 | 0.000122391 | 0.960765
8 x PLATINE | +0.000 | +0.102 | PL0(?) | 267 | PLATINE | 1 | 66.6 | 0.1 | 166 | 166 | 0.064 | 0.0001224 | 0.96084
2 x ATTACHE | +4.017 | +4.120 | AT0(?) | 267 | ATTACHE | 0.8 | 67 | 0.1 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
ATTACHE | +4.219 | +4.322 | AT0(?) | 267 | ATTACHE | 0.8 | 67 | 0.1 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
2 x ATTACHE | +4.373 | +4.476 | AT0(?) | 267 | ATTACHE | 0.8 | 67 | 0.1 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
2 x PLATINE | +2.062 | +2.104 | PL0(?) | 267 | PLATINE | 0.5 | 67.9 | 0 | 86 | 86 | 0.03456 | 0.0000648 | 0.50868
2 x PLATINE | +0.000 | +0.102 | PL0(?) | 267 | PLATINE | 0.8 | 66.8 | 0.1 | 146 | 146 | 0.05664 | 0.000108 | 0.8478
ATTACHE | +3.911 | +4.014 | AT0(?) | 267 | ATTACHE | 0.8 | 67 | 0.1 | 131.6 | 131.569 | 0.05112 | 0.0000972 | 0.76302
4 x ATTACHE | +4.108 | +4.293 | AT0(?) | 59 | ATTACHE | 1.1 | 66.4 | 0.1 | 190 | 190.013 | 0.0728369 | 0.00013969 | 1.09656

# IfcBeam: PL4*200 (67)
In: Undefined
Description: PL4*200; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes
Tekla Commun - Classe: 99; Matériau: S235JR; Profil: PL4*200
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 4 mm
Name | Reference = Repère de pièce = Repère d'assemblage | Niveau bas | Niveau haut | Phase | Nom | Poids (kg) | Surface par tonne (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
12 x PLATINE | PL0(?) | +0.187 | +0.229 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
16 x PLATINE | PL0(?) | +3.512 | +3.554 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
12 x PLATINE | PL0(?) | +2.062 | +2.104 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | PL0(?) | +0.187 | +0.229 | 252 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | PL0(?) | +3.410 | +3.452 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
2 x PLATINE | PL0(?) | +3.158 | +3.200 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
6 x ATTACHE | AT0(?) | +4.834 | +5.039 | 59 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
8 x ATTACHE | AT0(?) | +3.909 | +3.956 | 65 | ATTACHE | 1.2 | 66.3 | 0.1 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | AT0(?) | +4.098 | +4.303 | 3 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 189.993 | 0.0807492 | 0.000155195 | 1.21828
2 x ATTACHE | AT0(?) | +4.098 | +4.303 | 59 | ATTACHE | 1.2 | 66.3 | 0.1 | 190 | 190.013 | 0.0807574 | 0.000155211 | 1.2184
2 x PLATINE | PL0(?) | +3.156 | +3.199 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652
PLATINE | PL0(?) | +3.409 | +3.450 | 267 | PLATINE | 0.6 | 67.8 | 0 | 86 | 86 | 0.03832 | 0.000072 | 0.5652

# IfcBeam: SADEF-C+200X1.50 (119)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LISSE | STEEL/S235JR | +2.804 | +3.004 | LS0(?) | 1 | 14 | S235JR | LISSE | 7.7 | 0.1 | 1.4 | 1350 | 1350.01 | 1.16101 | 0.00102061 | 8.01177
LISSE | STEEL/S235JR | +3.204 | +3.404 | LS0(?) | 1 | 14 | S235JR | LISSE | 7.7 | 0.1 | 1.4 | 1350 | 1350.01 | 1.16101 | 0.00102061 | 8.01177
LISSE | STEEL/S235JR | +3.204 | +3.404 | LS0(?) | 1 | 14 | S235JR | LISSE | 49.4 | 0.9 | 8.8 | 8700 | 8700 | 7.482 | 0.0065772 | 51.631
LISSE | STEEL/S235JR | +2.804 | +3.004 | LS0(?) | 1 | 14 | S235JR | LISSE | 49.4 | 0.9 | 8.8 | 8700 | 8700 | 7.482 | 0.0065772 | 51.631
LISSE | STEEL/S235JR | +2.502 | +2.602 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +2.325 | +2.425 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +2.148 | +2.248 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.971 | +2.071 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.794 | +1.894 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.617 | +1.717 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.440 | +1.540 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.263 | +1.363 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +1.086 | +1.186 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.909 | +1.009 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.733 | +0.833 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.556 | +0.656 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.379 | +0.479 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.202 | +0.302 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
LISSE | STEEL/S235JR | +0.025 | +0.125 | LS0(?) | 1 | 14 | S235JR | LISSE | 4.5 | 0.2 | 0.8 | 801.5 | 801.5 | 0.68929 | 0.000605934 | 4.75658
4 x LISSE | STEEL/S235JR | +3.358 | +4.348 | LS0(?) | 1 | 14 | S235JR | LISSE | 22.5 | 0 | 4 | 3970.1 | 3970.13 | 3.41431 | 0.00300142 | 23.5611
LISSE | STEEL/S235JR | +4.148 | +4.348 | LS0(?) | 1 | 14 | S235JR | LISSE | 36.3 | 0.6 | 6.5 | 6400 | 6399.99 | 5.50399 | 0.0048384 | 37.9814
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 4.5 | 0.1 | 0.8 | 789.7 | 789.69 | 0.679133 | 0.000597005 | 4.68649
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 267 | 14 | S235JR | LISSE | 4.5 | 0.1 | 0.8 | 789.7 | 789.69 | 0.679133 | 0.000597005 | 4.68649
2 x LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 4.5 | 0.1 | 0.8 | 789.7 | 789.69 | 0.679133 | 0.000597005 | 4.68649
2 x PANNE | STEEL/S235JR | +4.177 | +4.390 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.364 | +4.577 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.555 | +4.768 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.732 | +4.945 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.271 | +4.483 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.651 | +4.864 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.083 | +4.296 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.819 | +5.032 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x PANNE | STEEL/S235JR | +4.458 | +4.671 | PA0(?) | 3 | 5 | S235JR | PANNE | 50.4 | 0 | 9 | 8882 | 8882 | 7.63852 | 0.00671479 | 52.7111
2 x LISSE | STEEL/S235JR | +4.083 | +5.041 | LS0(?) | 1 | 14 | S235JR | LISSE | 28.3 | 0 | 4.9 | 4992.3 | 4992.29 | 4.29337 | 0.00377417 | 29.6272
2 x LISSE | STEEL/S235JR | +4.271 | +4.483 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +4.651 | +4.864 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
LISSE | STEEL/S235JR | +2.404 | +2.604 | LS0(?) | 1 | 14 | S235JR | LISSE | 26.6 | 0.5 | 4.7 | 4690.9 | 4690.92 | 4.03419 | 0.00354634 | 27.8387
2 x LISSE | STEEL/S235JR | +2.204 | +3.204 | LS0(?) | 1 | 14 | S235JR | LISSE | 5.7 | 0 | 1 | 1000 | 1000 | 0.86 | 0.000756 | 5.9346
6 x LISSE | STEEL/S235JR | +2.204 | +2.404 | LS0(?) | 267 | 14 | S235JR | LISSE | 17 | 0.3 | 2.9 | 2999.8 | 2999.81 | 2.57984 | 0.00226786 | 17.8027
8 x LISSE | STEEL/S235JR | +2.404 | +2.604 | LS0(?) | 1 | 14 | S235JR | LISSE | 49.4 | 0.9 | 8.8 | 8700 | 8700 | 7.482 | 0.0065772 | 51.631
4 x LISSE | STEEL/S235JR | +2.404 | +2.604 | LS0(?) | 1 | 14 | S235JR | LISSE | 56.8 | 0.9 | 10.1 | 10000 | 10000 | 8.6 | 0.00756 | 59.346
LISSE | STEEL/S235JR | +2.404 | +2.604 | LS0(?) | 1 | 14 | S235JR | LISSE | 27.2 | 0.5 | 4.9 | 4790.9 | 4790.92 | 4.12019 | 0.00362194 | 28.4322
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.8 | 2.05523 | 0.00180669 | 14.1825
LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.8 | 2.05523 | 0.00180669 | 14.1825
LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.8 | 2.05523 | 0.00180669 | 14.1825
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 1.1 | 0 | 0.2 | 189.8 | 189.84 | 0.163262 | 0.000143519 | 1.12662
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 2.2 | 0 | 0.4 | 387.3 | 387.34 | 0.333112 | 0.000292829 | 2.29871
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 2.8 | 0 | 0.4 | 490 | 489.97 | 0.421374 | 0.000370417 | 2.90777
LISSE | STEEL/S235JR | +3.200 | +3.300 | LS0(?) | 267 | 14 | S235JR | LISSE | 28.3 | 0.3 | 4.9 | 4989.8 | 4989.84 | 4.29126 | 0.00377232 | 29.6127
LISSE | STEEL/S235JR | +3.310 | +3.410 | LS0(?) | 267 | 14 | S235JR | LISSE | 28.3 | 0.9 | 4.9 | 4989.8 | 4989.84 | 4.29126 | 0.00377232 | 29.6127
LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 28.3 | 0.3 | 4.9 | 4989.8 | 4989.84 | 4.29126 | 0.00377232 | 29.6127
LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 2.2 | 0 | 0.4 | 390 | 390.03 | 0.335426 | 0.000294863 | 2.31467
LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 267 | 14 | S235JR | LISSE | 2.2 | 0 | 0.4 | 387.3 | 387.34 | 0.333112 | 0.000292829 | 2.29871
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.81 | 2.05524 | 0.0018067 | 14.1826
2 x LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.81 | 2.05524 | 0.0018067 | 14.1826
2 x LISSE | STEEL/S235JR | +4.083 | +4.296 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +4.819 | +5.032 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +4.458 | +4.671 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +3.956 | +4.056 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.1 | 0.3 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x ARBA | STEEL/Steel_Undefined | +3.905 | +4.457 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 18.3 | 0 | 3.3 | 3221.9 | 3221.91 | 2.77085 | 0.00243577 | 19.1208
2 x ARBA | STEEL/Steel_Undefined | +4.261 | +4.815 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 18.4 | 0 | 3.3 | 3235.9 | 3235.94 | 2.78291 | 0.00244637 | 19.204
2 x ARBA | STEEL/Steel_Undefined | +3.903 | +4.814 | A0(?) | 1 | 6 | Steel_Undefined | ARBA | 37.3 | 0 | 6.7 | 6577.7 | 6577.69 | 5.65682 | 0.00497274 | 39.036
2 x LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +2.104 | +2.204 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +3.956 | +4.056 | LS0(?) | 65 | 14 | S235JR | LISSE | 27.7 | 0.3 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
LISSE | STEEL/S235JR | +0.229 | +0.329 | LS0(?) | 267 | 14 | S235JR | LISSE | 13.6 | 0.2 | 2.4 | 2389.8 | 2389.81 | 2.05524 | 0.0018067 | 14.1826
LISSE | STEEL/S235JR | +3.199 | +3.299 | LS0(?) | 267 | 14 | S235JR | LISSE | 17 | 0.3 | 2.9 | 2989.7 | 2989.68 | 2.57112 | 0.0022602 | 17.7425
LISSE | STEEL/S235JR | +3.309 | +3.409 | LS0(?) | 267 | 14 | S235JR | LISSE | 17 | 0.6 | 2.9 | 2989.7 | 2989.68 | 2.57112 | 0.0022602 | 17.7425
LISSE | STEEL/S235JR | +3.554 | +3.654 | LS0(?) | 267 | 14 | S235JR | LISSE | 17 | 0.3 | 2.9 | 2989.7 | 2989.68 | 2.57112 | 0.0022602 | 17.7425

# IfcBeam: SADEF-C+200X2.00 (32)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
POTEAU | +2.104 | +3.404 | P0(?) | 261 | 3 | POTEAU | 9.9 | 1.3 | 1300 | 1300 | 1.118 | 0.0013052 | 10.2458
2 x POTEAU | +0.005 | +4.093 | P0(?) | 267 | 3 | POTEAU | 31 | 4.1 | 4088.3 | 4088.33 | 3.51596 | 0.00410468 | 32.2218
2 x ARBA | +3.734 | +4.635 | AB0(?) | 261 | 7 | ARBA | 35 | 4.7 | 4613.5 | 4613.55 | 3.96765 | 0.004632 | 36.3612
6 x ARBA | +3.905 | +4.836 | AB0(?) | 261 | 7 | ARBA | 36.5 | 4.9 | 4817.2 | 4817.19 | 4.14278 | 0.00483646 | 37.9662
4 x ARBA | +4.077 | +5.039 | AB0(?) | 261 | 7 | ARBA | 38.1 | 5.1 | 5023.1 | 5023.11 | 4.31987 | 0.0050432 | 39.5891
2 x POTEAU | +0.000 | +3.404 | P0(?) | 261 | 3 | POTEAU | 25.8 | 3.4 | 3404 | 3404 | 2.92744 | 0.00341762 | 26.8283
3 x POTEAU | +0.000 | +2.404 | P0(?) | 261 | 3 | POTEAU | 18.2 | 2.4 | 2404 | 2404 | 2.06744 | 0.00241362 | 18.9469
POTEAU | +0.000 | +2.604 | P0(?) | 261 | 3 | POTEAU | 19.7 | 2.6 | 2604 | 2604 | 2.23944 | 0.00261442 | 20.5232
POTEAU | +0.005 | +4.296 | P0(?) | 267 | 3 | POTEAU | 32.5 | 4.3 | 4290.7 | 4290.69 | 3.68999 | 0.00430785 | 33.8166
2 x POTEAU | +0.005 | +4.450 | P0(?) | 267 | 3 | POTEAU | 33.7 | 4.5 | 4444.8 | 4444.8 | 3.82253 | 0.00446258 | 35.0312
POTEAU | +0.005 | +2.099 | P0(?) | 267 | 3 | POTEAU | 15.9 | 2.1 | 2094 | 2094 | 1.80084 | 0.00210238 | 16.5037
POTEAU | +0.005 | +3.987 | P0(?) | 267 | 3 | POTEAU | 30.2 | 4 | 3982.5 | 3982.47 | 3.42492 | 0.0039984 | 31.3874
3 x POTEAU | +0.000 | +4.067 | P0(?) | 261 | 3 | POTEAU | 30.8 | 4.1 | 4067 | 4067 | 3.49762 | 0.00408327 | 32.0537
3 x POTEAU | +0.000 | +3.900 | P0(?) | 261 | 3 | POTEAU | 29.6 | 4 | 3900.3 | 3900.26 | 3.35422 | 0.00391586 | 30.7395

# IfcColumn: SADEF-C+200X1.50 (2)
In: Undefined
Description: SADEF-C+200X1.50; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.204; Niveau haut: +3.204; Repère de pièce: LS0(?); Repère d'assemblage: LS0(?); Phase: 1; Classe: 14; Matériau: S235JR; Profil: SADEF-C+200X1.50; Nom: LISSE
Tekla Quantités - Poids: 5.7 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Surface nette: 1 m2; Hauteur: 200 mm; Largeur: 100 mm; Longueur: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 0.86 m2; NetVolume: 0.000756 m3; NetWeight: 5.9346 kg
Pset_ColumnCommon - LoadBearing: yes; Reference: LS0(?)

# IfcColumn: SADEF-C+200X2.00 (13)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Classe: 3; Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: P0(?)
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | +0.005 | +4.093 | 267 | 31 | 4.1 | 4088.3 | 4088.33 | 3.51596 | 0.00410468 | 32.2218
POTEAU | +0.005 | +4.296 | 267 | 32.5 | 4.3 | 4290.7 | 4290.69 | 3.68999 | 0.00430785 | 33.8166
2 x POTEAU | +0.005 | +4.450 | 267 | 33.7 | 4.5 | 4444.8 | 4444.8 | 3.82253 | 0.00446258 | 35.0312
POTEAU | +0.005 | +2.099 | 267 | 15.9 | 2.1 | 2094 | 2094 | 1.80084 | 0.00210238 | 16.5037
POTEAU | +0.005 | +3.987 | 267 | 30.2 | 4 | 3982.5 | 3982.47 | 3.42492 | 0.0039984 | 31.3874
3 x POTEAU | +0.000 | +4.067 | 261 | 30.8 | 4.1 | 4067 | 4067 | 3.49762 | 0.00408327 | 32.0537
3 x POTEAU | +0.000 | +3.900 | 261 | 29.6 | 4 | 3900.3 | 3900.26 | 3.35422 | 0.00391586 | 30.7395

# IfcElementAssembly (389)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm) | PredefinedType
Steel Assembly | 52644.3 | -0.200 | +0.000 | 1-5/<A | Da0(?) | 200
Steel Assembly | 7.7 | +2.804 | +3.004 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 7.7 | +3.204 | +3.404 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 9.9 | +2.104 | +3.404 | 1-2/<A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 49.4 | +3.204 | +3.404 | 1-5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 49.4 | +2.804 | +3.004 | 1-5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +2.502 | +2.602 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +2.325 | +2.425 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +2.148 | +2.248 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.971 | +2.071 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.794 | +1.894 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.617 | +1.717 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.440 | +1.540 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.263 | +1.363 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +1.086 | +1.186 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.909 | +1.009 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.733 | +0.833 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.556 | +0.656 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.379 | +0.479 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.202 | +0.302 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.025 | +0.125 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.1 | -0.005 | +2.595 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 16.1 | -0.005 | +2.595 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 1 | -0.000 | +0.102 | 3/<A | PL0(?) | 72 | RIGID_FRAME
4 x Steel Assembly | 1 | -0.000 | +0.102 | 1-2/<A | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 25.8 | +0.000 | +3.404 | 3/<A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 18.2 | +0.000 | +2.404 | 3/<A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 25.8 | +0.000 | +3.404 | 1-2/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 18.2 | +0.000 | +2.404 | 1-2/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1 | +0.000 | +0.102 | 5/<A | PL0(?) | 71.9967 | RIGID_FRAME
2 x Steel Assembly | 1 | +0.000 | +0.102 | 3/<A | PL0(?) | 71.9934 | RIGID_FRAME
2 x Steel Assembly | 1 | +0.000 | +0.102 | 1/<A | PL0(?) | 71.9934 | RIGID_FRAME
5 x Steel Assembly | 1 | +0.000 | +0.102 | 5/<A | PL0(?) | 72 | RIGID_FRAME
2 x Steel Assembly | 1 | -0.000 | +0.102 | 1/<A | PL0(?) | 72 | RIGID_FRAME
Steel Assembly | 19.7 | +0.000 | +2.604 | 1-2/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 30.8 | +0.000 | +4.067 | 5/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 29.6 | +0.000 | +3.900 | 5/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 30.8 | +0.000 | +4.067 | 3/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 29.6 | +0.000 | +3.900 | 3/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 30.8 | +0.000 | +4.067 | 1/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 29.6 | +0.000 | +3.900 | 1/<A | P0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 22.5 | +3.358 | +4.348 | <1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 36.3 | +4.148 | +4.348 | <1/<A | LS0(?) | 100 | RIGID_FRAME
6 x Steel Assembly | 0.6 | +0.187 | +0.229 | 1/<A | PL0(?) | 52 | RIGID_FRAME
8 x Steel Assembly | 0.6 | +3.512 | +3.554 | 1/<A | PL0(?) | 52 | RIGID_FRAME
6 x Steel Assembly | 0.6 | +2.062 | +2.104 | 1/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 4.5 | +0.229 | +0.329 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +2.104 | +2.204 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +3.554 | +3.654 | 1/<A | LS0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 31 | +0.005 | +4.093 | 1/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +4.017 | +4.120 | 1/<A | AT0(?) | 41.8379 | RIGID_FRAME
3 x Steel Assembly | 1 | +0.000 | +0.102 | 1/<A | PL0(?) | 72 | RIGID_FRAME
2 x Steel Assembly | 35 | +3.734 | +4.635 | 1/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 36.5 | +3.905 | +4.836 | 1/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.352 | +4.953 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.271 | +4.872 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.175 | +4.775 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.078 | +4.679 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +3.984 | +4.585 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +3.890 | +4.491 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 6.3 | +3.754 | +4.336 | 1/<A | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 1 | +3.797 | +4.397 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.177 | +4.390 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.364 | +4.577 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.555 | +4.768 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.732 | +4.945 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.271 | +4.483 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.651 | +4.864 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.083 | +4.296 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.819 | +5.032 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 50.4 | +4.458 | +4.671 | <1-3/<A | PA0(?) | 100 | RIGID_FRAME
Steel Assembly | 9 | +4.347 | +5.045 | 1/<A | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 28.3 | +4.083 | +5.041 | <1/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.232 | +4.342 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.420 | +4.530 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.610 | +4.720 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.787 | +4.898 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 36.5 | +3.905 | +4.836 | 5/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 38.1 | +4.077 | +5.039 | 5/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 36.5 | +3.905 | +4.836 | 3/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 38.1 | +4.077 | +5.039 | 3/<A | AB0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +4.088 | +4.491 | 5/<A | CO0(?) | 50.0001 | RIGID_FRAME
4 x Steel Assembly | 0.6 | +4.088 | +4.491 | 3/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.326 | +4.436 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +4.271 | +4.483 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +4.469 | +4.872 | 5/<A | CO0(?) | 50.0001 | RIGID_FRAME
3 x Steel Assembly | 0.6 | +4.469 | +4.872 | 3/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.707 | +4.817 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +4.651 | +4.864 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 26.6 | +2.404 | +2.604 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 17 | +2.204 | +2.404 | 5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 5.7 | +2.204 | +3.204 | 5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 17 | +2.204 | +2.404 | 3/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 17 | +2.204 | +2.404 | 1-2/<A | LS0(?) | 100 | RIGID_FRAME
8 x Steel Assembly | 49.4 | +2.404 | +2.604 | 1-5/<A | LS0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 56.8 | +2.404 | +2.604 | 1-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 5.7 | +2.204 | +3.204 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 27.2 | +2.404 | +2.604 | 1-3/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 17 | +2.204 | +2.404 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 4.5 | +0.229 | +0.329 | 5/<A | LS0(?) | 100 | RIGID_FRAME
8 x Steel Assembly | 0.6 | +0.187 | +0.229 | 5/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 4.5 | +2.104 | +2.204 | 5/<A | LS0(?) | 100 | RIGID_FRAME
6 x Steel Assembly | 0.6 | +2.062 | +2.104 | 5/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 4.5 | +3.554 | +3.654 | 5/<A | LS0(?) | 100 | RIGID_FRAME
8 x Steel Assembly | 0.6 | +3.512 | +3.554 | 5/<A | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 32.5 | +0.005 | +4.296 | 5/<A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.8 | +4.219 | +4.322 | 5/<A | AT0(?) | 41.8379 | RIGID_FRAME
2 x Steel Assembly | 33.7 | +0.005 | +4.450 | 1/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 13.6 | +0.229 | +0.329 | 1/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 13.6 | +2.104 | +2.204 | 1/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 13.6 | +3.554 | +3.654 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 1.1 | +0.229 | +0.329 | 5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 33.7 | +0.005 | +4.450 | 5/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 30.2 | +0.005 | +3.987 | 5/<A | P0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.410 | +3.452 | 5/<A | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.158 | +3.200 | 5/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.8 | +4.373 | +4.476 | 1/<A | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 2.8 | +0.229 | +0.329 | 5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.5 | +2.062 | +2.104 | 5/<A | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 0.8 | +0.000 | +0.102 | 5/<A | PL0(?) | 52 | RIGID_FRAME
2 x Steel Assembly | 15.9 | +0.005 | +2.099 | 5/<A | P0(?) | 100 | RIGID_FRAME
Steel Assembly | 13.6 | +2.104 | +2.204 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.2 | +0.229 | +0.329 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.8 | +4.373 | +4.476 | 5/<A | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 28.3 | +3.200 | +3.300 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 28.3 | +3.310 | +3.410 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 28.3 | +3.554 | +3.654 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 2.2 | +3.554 | +3.654 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 0.8 | +3.911 | +4.014 | 5/<A | AT0(?) | 41.8379 | RIGID_FRAME
Steel Assembly | 2.2 | +2.104 | +2.204 | 5/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 13.6 | +3.554 | +3.654 | 5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.104 | +2.204 | 5/<A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.556 | +3.656 | 5/<A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.229 | +0.329 | 5/<A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 1.1 | +4.108 | +4.293 | 5/<A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +4.083 | +4.296 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.1 | +4.108 | +4.293 | 3/<A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.834 | +5.039 | 5/<A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.834 | +5.039 | 3/<A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +4.819 | +5.032 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +4.276 | +4.679 | 5/<A | CO0(?) | 50.0001 | RIGID_FRAME
4 x Steel Assembly | 0.6 | +4.276 | +4.679 | 3/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +4.458 | +4.671 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 16.1 | +0.332 | +2.104 | 4-5/<A | A0(?) | 100 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +1.935 | +2.264 | 4/<A | PL0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 16.1 | +2.107 | +3.867 | 3-4/<A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +0.344 | +0.494 | 5/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.704 | +3.854 | 3/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 33.1 | +0.332 | +3.867 | 3-5/<A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +3.909 | +3.956 | 5/<A | AT0(?) | 166.003 | RIGID_FRAME
4 x Steel Assembly | 1.2 | +3.909 | +3.956 | 3/<A | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +3.956 | +4.056 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.054 | +2.104 | 5/<A | CO0(?) | 50.0001 | RIGID_FRAME
4 x Steel Assembly | 0.6 | +2.054 | +2.104 | 3/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +2.104 | +2.204 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 5/<A | CO0(?) | 50.0001 | RIGID_FRAME
4 x Steel Assembly | 0.6 | +0.179 | +0.229 | 3/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 27.1 | +0.229 | +0.329 | 3-5/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +0.344 | +0.494 | 3/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.704 | +3.854 | 5/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +4.592 | +4.823 | 3/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 18.3 | +3.905 | +4.457 | 3-4/<A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.433 | +4.487 | 4/<A | PL0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.231 | +4.286 | 4/<A | PL0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.899 | +4.130 | 3/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 18.4 | +4.261 | +4.815 | 4-5/<A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +4.592 | +4.823 | 5/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 37.3 | +3.903 | +4.814 | 3-5/<A | A0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 2.9 | +3.895 | +4.126 | 5/<A | A0(?) | 210 | RIGID_FRAME
2 x Steel Assembly | 6.9 | +3.754 | +4.336 | 5/<A | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 6.9 | +3.754 | +4.336 | 3/<A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +4.595 | +5.045 | 3/<A | G0(?) | 4 | RIGID_FRAME
Steel Assembly | 8.3 | +4.595 | +5.045 | 5/<A | G0(?) | 4 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.874 | +4.985 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.834 | +5.039 | 1/<A | AT0(?) | 151.013 | RIGID_FRAME
2 x Steel Assembly | 1 | +4.138 | +4.249 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.098 | +4.303 | 3/<A | AT0(?) | 150.993 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +4.098 | +4.303 | 1/<A | AT0(?) | 151.013 | RIGID_FRAME
Steel Assembly | 1 | +4.514 | +4.624 | 3/<A | AT0(?) | 254.983 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.179 | +0.229 | 1/<A | CO0(?) | 50.0001 | RIGID_FRAME
2 x Steel Assembly | 27.7 | +0.229 | +0.329 | 1-3/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 27.7 | +2.104 | +2.204 | 1-3/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 1.2 | +3.909 | +3.956 | 1/<A | AT0(?) | 166.003 | RIGID_FRAME
2 x Steel Assembly | 27.7 | +3.956 | +4.056 | 1-3/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +2.104 | +2.204 | 1/<A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.556 | +3.656 | 1/<A | PLA0(?) | 2 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +0.229 | +0.329 | 1/<A | PLA0(?) | 2 | RIGID_FRAME
Steel Assembly | 17 | +3.554 | +3.654 | 1/<A | LS0(?) | 100 | RIGID_FRAME
2 x Steel Assembly | 0.6 | +3.156 | +3.199 | 1/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 0.6 | +3.409 | +3.450 | 1/<A | PL0(?) | 52 | RIGID_FRAME
Steel Assembly | 17 | +3.199 | +3.299 | 1/<A | LS0(?) | 100 | RIGID_FRAME
Steel Assembly | 17 | +3.309 | +3.409 | 1/<A | LS0(?) | 100 | RIGID_FRAME

# IfcMechanicalFastener: Bolt assembly (5058)
In: Undefined
Material: 8.8
Tekla Boulons - Quantité de rondelle: 0; Type rondelle: PLA-8.8; Type écrou: E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage; Standard: 8.8
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) | Nom rondelle | Quantité d'écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Longueur (mm) | Nom
3338 x Bolt assembly | 12 | 2 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 2 | M12*25
576 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 2 | ECROU-M12-E-8.8 | 14 | 2 | 25 | M12*25
26 x Bolt assembly | 24 | 4 | RONDELLE-M24-PLA-8.8 | 0 | ECROU-M24-E-8.8 | 26 | 1 | 4 | M24*50
214 x Bolt assembly | 12 | 1.5 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 1.5 | M12*25
384 x Bolt assembly | 12 | 2 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 2 | M12*25
14 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 6 | ECROU-M12-E-8.8 | 14 | 6 | 25 | M12*25
61 x Bolt assembly | 12 | 4 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
174 x Bolt assembly | 12 | 1.5 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
78 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 4 | ECROU-M12-E-8.8 | 14 | 4 | 25 | M12*25
12 x Bolt assembly | 16 | 25 | RONDELLE-M16-PLA-8.8 | 1 | ECROU-M16-E-8.8 | 18 | 1 | 25 | M16*25
16 x Bolt assembly | 12 | 4.0002 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 2 | 4 | M12*25
100 x Bolt assembly | 12 | 25 | RONDELLE-M12-PLA-8.8 | 1 | ECROU-M12-E-8.8 | 14 | 1 | 25 | M12*25
59 x Bolt assembly | 12 | 1.50019 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 1.5 | M12*25
4 x Bolt assembly | 12 | 4 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 1 | 4 | M12*25
2 x Bolt assembly | 12 | 4 | RONDELLE-M12-PLA-8.8 | 0 | ECROU-M12-E-8.8 | 14 | 4 | 4 | M12*25

# IfcMember: SADEF-C+200X1.50 (8)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Phase: 1; Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x LISSE | STEEL/S235JR | -0.005 | +2.595 | LS0(?) | 14 | S235JR | LISSE | 16.1 | 2.9 | 2836.9 | 2836.89 | 2.43973 | 0.00214469 | 0.00205107 | 16.8358 | 16.1009
2 x ARBA | STEEL/Steel_Undefined | +0.332 | +2.104 | A0(?) | 6 | Steel_Undefined | ARBA | 16.1 | 2.9 | 2860 | 2860.01 | 2.45961 | 0.00216217 | 0.00206779 | 16.973 | 16.2321
2 x ARBA | STEEL/Steel_Undefined | +2.107 | +3.867 | A0(?) | 6 | Steel_Undefined | ARBA | 16.1 | 2.9 | 2839.4 | 2839.41 | 2.44189 | 0.00214659 | 0.00205289 | 16.8507 | 16.1152
2 x ARBA | STEEL/Steel_Undefined | +0.332 | +3.867 | A0(?) | 6 | Steel_Undefined | ARBA | 33.1 | 5.9 | 5840 | 5839.98 | 5.02238 | 0.00441502 | 0.0042223 | 34.6579 | 33.1451

# IfcPlate: 200*10200, DALLE
In: Undefined
Description: 200*10200; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.200; Niveau haut: +0.000; Repère de pièce: Da0(?); Repère d'assemblage: Da0(?); Phase: 1; Classe: 13; Matériau: VERRE; Profil: 200*10200; Nom: DALLE
Tekla Quantités - Poids: 52644.3 kg; Volume: 20.8 m3; Surface supérieure totale: 104 m2; Surface par tonne: 4.1 m2; Surface nette: 216.2 m2; Hauteur: 10200 mm; Largeur: 200 mm; Longueur: 10200 mm
Pset_PlateCommon - LoadBearing: yes; Reference: Da0(?)
BaseQuantities - Width: 10200 mm; NetArea: 216.24 m2; GrossArea: 104.04 m2; CrossSectionArea: 0.04 m2; NetVolume: 20.808 m3; GrossVolume: 20.808 m3

# IfcPlate: PL2*100 (12)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Phase: 267; Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Poids: 0.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.6 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 400 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 100 mm; NetArea: 0.082 m2; GrossArea: 0.04 m2; CrossSectionArea: 0.000004 m2; NetVolume: 0.00008 m3; GrossVolume: 0.00008 m3
Name | Niveau bas | Niveau haut
4 x PLAT | +2.104 | +2.204
4 x PLAT | +3.556 | +3.656
4 x PLAT | +0.229 | +0.329

# IfcPlate: PL4*100 (8)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Poids: 1.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x PLAT | +1.935 | +2.264 | 265 | 66.8 | 420 | 0.0881704 | 0.042005 | 0.00016802
2 x PLAT | +4.433 | +4.487 | 264 | 67 | 370 | 0.0777704 | 0.037005 | 0.00014802
2 x PLAT | +4.231 | +4.286 | 264 | 67 | 370 | 0.0777704 | 0.037005 | 0.00014802

# IfcPlate: PL4*400 (4)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +3.754; Niveau haut: +4.336; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 261; Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3

# IfcPlate: PL4*450 (2)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +4.595; Niveau haut: +5.045; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 260; Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 682.4 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.537583 m2; GrossArea: 0.307168 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00105873 m3; GrossVolume: 0.00105873 m3

# IfcPlate: PL4*582 (2)
In: Undefined
Description: PL4*582; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +3.754; Niveau haut: +4.336; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL4*582; Nom: GOUSSET
Tekla Quantités - Poids: 6.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65 m2; Surface nette: 0.4 m2; Hauteur: 581.9 mm; Largeur: 4 mm; Longueur: 480.3 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 581.948 mm; NetArea: 0.407157 m2; GrossArea: 0.27952 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000797535 m3; GrossVolume: 0.000797535 m3

# IfcPlate: PL4*614, GOUSSET
In: Undefined
Description: PL4*614; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +4.347; Niveau haut: +5.045; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL4*614; Nom: GOUSSET
Tekla Quantités - Poids: 9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.6 m2; Hauteur: 613.6 mm; Largeur: 4 mm; Longueur: 726.7 mm
BaseQuantities - Width: 613.602 mm; NetArea: 0.584589 m2; GrossArea: 0.445885 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00114935 m3; GrossVolume: 0.00114935 m3
